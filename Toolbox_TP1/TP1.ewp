# IAR project TP1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152ZE ST STM32L152ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_XL
  ICCARM.CCIncludePath2: Libraries\CMSIS\Device\ST\STM32L1xx\Include; Libraries\STM32L1xx_StdPeriph_Driver\inc; Libraries\STM32L1xx_StdPeriph_Driver\src; Libraries\CMSIS\Include; ; Libraries\CMSIS\Device\ST\STM32L1xx\Source\Templates\iar; Libraries\stm32l1xx_nucleo
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TP1.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32l152xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: main.c main_1_2.c main_7segments.c main_7segments_V2.c main_Buzzer.c main_Chenillard_V1.c main_Chenillard_V2.c main_Chenillard_V3.c main_Motor.c main_TIMER2.c MUSIC_MARIO.c stm32l1xx_it.c
  group CMSIS
    Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/iar/: startup_stm32l1xx_xl.s
  group CMSIS/STM32L1xx/Include
    Libraries/CMSIS/Device/ST/STM32L1xx/Include/: stm32l1xx.h system_stm32l1xx.h
  group CMSIS/STM32L1xx/Source
    Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
  group stm32l1xx_nucleo
    Libraries/stm32l1xx_nucleo/: stm32l1xx_nucleo.c stm32l1xx_nucleo.h
  group STM32L1xx_StdPeriph_Driver/inc
    Libraries/STM32L1xx_StdPeriph_Driver/inc/: misc.h stm32l1xx_adc.h stm32l1xx_aes.h stm32l1xx_comp.h stm32l1xx_crc.h stm32l1xx_dac.h stm32l1xx_dbgmcu.h stm32l1xx_dma.h stm32l1xx_exti.h stm32l1xx_flash.h stm32l1xx_fsmc.h stm32l1xx_gpio.h stm32l1xx_i2c.h stm32l1xx_iwdg.h stm32l1xx_lcd.h stm32l1xx_opamp.h stm32l1xx_pwr.h stm32l1xx_rcc.h stm32l1xx_rtc.h stm32l1xx_sdio.h stm32l1xx_spi.h stm32l1xx_syscfg.h stm32l1xx_tim.h stm32l1xx_usart.h stm32l1xx_wwdg.h
  group STM32L1xx_StdPeriph_Driver/src
    Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
